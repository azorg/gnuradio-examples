<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtl2832_fmradio_stereo</value></param>
<param><key>title</key><value>Stereo FM Radio</value></param>
<param><key>author</key><value>Alex Grinkov</value></param>
<param><key>description</key><value>FM receiver (stereo)</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-xlate_tune</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>Receive</value></param>
<param><key>value</key><value>tuner_freq+xlate_tune</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_tune</value></param>
<param><key>label</key><value>Fine frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-1e6</value></param>
<param><key>max</key><value>1e6</value></param>
<param><key>num_steps</key><value>160</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gr_complex_to_imag</key>
<param><key>id</key><value>gr_complex_to_imag_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>filter_taps</value></param>
<param><key>width</key><value>10000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tuner_freq</value></param>
<param><key>label</key><value>frequency</value></param>
<param><key>value</key><value>99.6e6</value></param>
<param><key>min</key><value>88e6</value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_fcc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>dsp_samp_rate</value></param>
<param><key>low_cutoff_freq</key><value>18900</value></param>
<param><key>high_cutoff_freq</key><value>19100</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_fm_demod_cf</key>
<param><key>id</key><value>blks2_fm_demod_cf_0</value></param>
<param><key>chan_rate</key><value>samp_rate/10</value></param>
<param><key>audio_decim</key><value>2</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>audio_pass</key><value>57000</value></param>
<param><key>audio_stop</key><value>58000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fftsink_rf</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Baseband</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-40</value></param>
<param><key>ref_scale</key><value>13490.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>10</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>window.flattop</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>rtl2832_source</key>
<param><key>id</key><value>rtl2832_source_0</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>frequency</key><value>tuner_freq</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>relative_gain</key><value>True</value></param>
<param><key>gain</key><value>rf_gain</value></param>
<param><key>gain_mode</key><value></value></param>
<param><key>auto_gain_mode</key><value>False</value></param>
<param><key>usb_vid</key><value>0x0</value></param>
<param><key>usb_pid</key><value>0x0</value></param>
<param><key>tuner_name</key><value></value></param>
<param><key>read_length</key><value>0</value></param>
<param><key>xfer_timeout</key><value>0</value></param>
<param><key>use_buffer</key><value>True</value></param>
<param><key>buf_mul</key><value>0</value></param>
<param><key>buf_level</key><value>0</value></param>
<param><key>fir_coeffs</key><value>[]</value></param>
<param><key>xtal_freq</key><value>0</value></param>
</block>
<block>
<key>gr_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>120e3</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>stereo</value></param>
<param><key>label</key><value>Stereo</value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>1</value></param>
<param><key>false</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dsp_samp_rate</value></param>
<param><key>value</key><value>samp_rate/10/2</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>dsp_samp_rate</value></param>
<param><key>low_cutoff_freq</key><value>37900</value></param>
<param><key>high_cutoff_freq</key><value>38100</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>gr_pll_refout_cc</key>
<param><key>id</key><value>gr_pll_refout_cc_0</value></param>
<param><key>w</key><value>0.001</value></param>
<param><key>max_freq</key><value>2*3.1415926*18900/dsp_samp_rate</value></param>
<param><key>min_freq</key><value>2*3.1415926*19100/dsp_samp_rate</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>dsp_samp_rate</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>dsp_samp_rate</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>rr_stereo_right_1</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>dsp_samp_rate/2/1000</value></param>
<param><key>interp</key><value>audio_rate/1000</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>rr_stereo_right_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>dsp_samp_rate/2/1000</value></param>
<param><key>interp</key><value>audio_rate/1000</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>2*stereo</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>af_gain_stereo_left_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>af_gain_stereo_left_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blks2_fm_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_pll_refout_cc_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_pll_refout_cc_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_1</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_complex_to_imag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_demod_cf_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rr_stereo_right_1</source_block_id><sink_block_id>af_gain_stereo_left_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rr_stereo_right_0</source_block_id><sink_block_id>af_gain_stereo_left_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_2</source_block_id><sink_block_id>low_pass_filter_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>rr_stereo_right_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>rr_stereo_right_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_complex_to_imag_0</source_block_id><sink_block_id>gr_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_demod_cf_0</source_block_id><sink_block_id>gr_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>af_gain_stereo_left_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>af_gain_stereo_left_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>fftsink_rf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
