<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_lpd_recv</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fine_tune</value></param>
<param><key>label</key><value>Fine frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-0.1e6</value></param>
<param><key>max</key><value>0.1e6</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-50</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>10</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-fine_tune</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>af_gain_stereo_left</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>f0</value></param>
<param><key>value</key><value>433075000</value></param>
<param><key>min</key><value>433000000</value></param>
<param><key>max</key><value>434000000</value></param>
<param><key>num_steps</key><value>80</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>100000</value></param>
<param><key>cutoff_freq</key><value>6000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>100000</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>48</value></param>
<param><key>interp</key><value>100</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>.1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>100000</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>20</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>af_gain_stereo_left</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>af_gain_stereo_left</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>af_gain_stereo_left</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
